<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fmcw_sonar</value></param>
<param><key>author</key><value>Chris Kuethe &lt;chris.kuethe@gmail.com&gt;</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Frequency Modulated Continuous Wave Sonar</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>beamformer_hz</value></param>
<param><key>value</key><value>beamformer_rate if beamformer_rate &gt;= 0 else -1.0/beamformer_rate</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>beamformer_rate</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>label</key><value>beam scan/sec</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-10</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>10</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>chirp_bw</value></param>
<param><key>value</key><value>samp_rate/2</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>chirp bandwidth</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>samp_rate/20</value></param>
<param><key>stop</key><value>2*samp_rate</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>chirp_rate</value></param>
<param><key>value</key><value>50</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>chirps/sec</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>5</value></param>
<param><key>stop</key><value>250</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>crossfeed_gain</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.005</value></param>
<param><key>stop</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gui_fps</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>v_ms</value></param>
<param><key>value</key><value>343</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>label0</key><value>Mach 1</value></param>
<param><key>label1</key><value>Warp 1</value></param>
<param><key>label</key><value>Propagation Velocity</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>343</value></param>
<param><key>option1</key><value>3e8</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>device_name</key><value>hw:1,0</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_1</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>samp_rate/40</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>40.0/samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0_0</value></param>
<param><key>length</key><value>samp_rate/40</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>40.0/samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>crossfeed_gain</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>chirp_gen</key>
<param><key>id</key><value>chirp_gen_0</value></param>
<param><key>bf_hz</key><value>beamformer_hz</value></param>
<param><key>chirp_rate_hz</key><value>chirp_rate</value></param>
<param><key>chirp_width_hz</key><value>chirp_bw</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>fosphor_qt_sink_c</key>
<param><key>id</key><value>fosphor_qt_sink_c_0</value></param>
<param><key>freq_center</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
</block>
<block>
<key>hilbert_fc</key>
<param><key>id</key><value>hilbert_fc_0</value></param>
<param><key>num_taps</key><value>65</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Sweep Phase</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value></value></param>
<param><key>update_time</key><value>1.0/gui_fps</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Mic</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Crossfeed</value></param>
<param><key>name</key><value>Mixer Balance</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>1.0/gui_fps</value></param>
<param><key>ymax</key><value>0.05</value></param>
<param><key>ymin</key><value>-0.05</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1.0/gui_fps</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>audio_source_0_0</source_block_id><sink_block_id>blocks_moving_average_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0_0</source_block_id><sink_block_id>hilbert_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_1</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_complex_to_real_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chirp_gen_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chirp_gen_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chirp_gen_0</source_block_id><sink_block_id>fosphor_qt_sink_c_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chirp_gen_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chirp_gen_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hilbert_fc_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
