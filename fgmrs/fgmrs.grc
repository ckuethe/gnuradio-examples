<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>channel_width</value></param>
<param><key>value</key><value>25e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>(int(rf_freq_mhz)+0.5)*1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>int(11025)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_freq</value></param>
<param><key>value</key><value>rf_freq_mhz*1.0e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>spec_size</value></param>
<param><key>value</key><value>480,256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimated_rate</value></param>
<param><key>value</key><value>samp_rate/decimation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>int(samp_rate/channel_width)</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>rf_freq</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>variable_chooser_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Push To Talk</value></param>
<param><key>value</key><value>0</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>labels</key><value>['Listen', 'Talk']</value></param>
<param><key>type</key><value>button</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>cctss_freq</value></param>
<param><key>label</key><value>Privacy Code</value></param>
<param><key>value</key><value>0</value></param>
<param><key>choices</key><value>[0,67.0,71.9,74.4,77.0,79.7,82.5,85.4,88.5,91.5,94.8,97.4,100.0,103.5,107.2,110.9,114.8,118.8,123.0,127.3,131.8,136.5,141.3,146.2,151.4,156.7,162.2,167.9,173.8,179.9,186.2,192.8,203.5,210.7,218.1,225.7,233.7,241.8,250.3]</value></param>
<param><key>labels</key><value>['0 (Monitor)',1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38]</value></param>
<param><key>type</key><value>drop_down</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>3,2,1,1</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>int(audio_rate)</value></param>
<param><key>decim</key><value>int(decimated_rate)</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>rf_freq_mhz</value></param>
<param><key>label</key><value>Channel</value></param>
<param><key>value</key><value>462.5625</value></param>
<param><key>choices</key><value>[462.5625, 462.5875, 462.6125, 462.6375, 462.6625, 462.6875, 462.7125, 467.5625, 467.5875, 467.6125, 467.6375, 467.6625, 467.6875, 467.7125, 462.550, 462.575, 462.600, 462.625,462.650,462.675,462.700, 462.725]</value></param>
<param><key>labels</key><value>['FRS1 / GMRS 9',2,3,4,5,6,'FRS7 / GMRS15 ','FRS8',9,10,11,12,13,'FRS14','GMRS1',2,3,4,5,6,7,'GMRS8']</value></param>
<param><key>type</key><value>drop_down</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>3,1,1,1</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>quad_rate</key><value>audio_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
<param><key>max_dev</key><value>5e3</value></param>
</block>
<block>
<key>analog_ctcss_squelch_ff</key>
<param><key>id</key><value>analog_ctcss_squelch_ff_0</value></param>
<param><key>rate</key><value>audio_rate</value></param>
<param><key>freq</key><value>cctss_freq</value></param>
<param><key>level</key><value>0.01</value></param>
<param><key>len</key><value>0</value></param>
<param><key>ramp</key><value>1</value></param>
<param><key>gate</key><value>False</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>threshold</key><value>squelch</value></param>
<param><key>alpha</key><value>0.0001</value></param>
<param><key>ramp</key><value>1</value></param>
<param><key>gate</key><value>False</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>squelch</value></param>
<param><key>label</key><value>Squelch (dBm)</value></param>
<param><key>value</key><value>-20</value></param>
<param><key>min</key><value>-50</value></param>
<param><key>max</key><value>0</value></param>
<param><key>num_steps</key><value>50</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>3,3,1,2</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>decimation</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>decimated_rate*0.8</value></param>
<param><key>width</key><value>decimated_rate*0.2</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Baseband Spectrum</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>40</value></param>
<param><key>ref_level</key><value>-25</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>spec_size</value></param>
<param><key>grid_pos</key><value>1,4,1,3</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>type</key><value>cc</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>20</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>RF Spectrum</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>center_freq</value></param>
<param><key>dynamic_range</key><value>40</value></param>
<param><key>ref_level</key><value>-25</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>spec_size</value></param>
<param><key>grid_pos</key><value>1,1,1,3</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Raw Audio Spectrum</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>40</value></param>
<param><key>ref_level</key><value>-25</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>spec_size</value></param>
<param><key>grid_pos</key><value>2,4,1,3</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Squelched Audio Spectrum</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>40</value></param>
<param><key>ref_level</key><value>-25</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>spec_size</value></param>
<param><key>grid_pos</key><value>2,1,1,3</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>fgmrs_rx</value></param>
<param><key>title</key><value>[FG]MRS Receiver</value></param>
<param><key>author</key><value>Chris Kuethe &lt;chris.kuethe@gmail.com&gt;</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>analog_nbfm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_0</source_block_id><sink_block_id>wxgui_waterfallsink2_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_0</source_block_id><sink_block_id>analog_ctcss_squelch_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_ctcss_squelch_ff_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>wxgui_waterfallsink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
