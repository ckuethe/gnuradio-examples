<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>title</key><value>ISM Explorer</value></param>
<param><key>author</key><value>Chris Kuethe &lt;chris.kuethe@gmail.com&gt;</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_freq</value></param>
<param><key>value</key><value>tuner_freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>configfile</value></param>
<param><key>value</key><value>'ism_explorer.ini'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(8e6)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_rate</value></param>
<param><key>value</key><value>samp_rate/decimation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tuner_freq</value></param>
<param><key>value</key><value>(tuner_mhz+0.5)*1.0e6</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>http://www.maximintegrated.com/en/app-notes/index.mvp/id/3587</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>type</key><value>cc</value></param>
<param><key>length</key><value>128</value></param>
<param><key>long_form</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>channel_freq</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>decim</key><value>decimation</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>tuner_freq</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ifgain</value></param>
<param><key>label</key><value>IF Gain</value></param>
<param><key>value</key><value>config_bbgain</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>40</value></param>
<param><key>num_steps</key><value>5</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>1,3,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>bbgain</value></param>
<param><key>label</key><value>BB Gain</value></param>
<param><key>value</key><value>config_bbgain</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>62</value></param>
<param><key>num_steps</key><value>31</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>1,2,1,1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>ppmcorr</value></param>
<param><key>label</key><value>PPM</value></param>
<param><key>value</key><value>config_ppmcorr</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_bbgain</value></param>
<param><key>value</key><value>24</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>configfile</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>bbgain</value></param>
<param><key>writeback</key><value>bbgain</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_ppmcorr</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>configfile</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>ppmcorr</value></param>
<param><key>writeback</key><value>ppmcorr</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_ismband</value></param>
<param><key>value</key><value>915</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>configfile</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>ismband</value></param>
<param><key>writeback</key><value>ismband</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tuner_mhz</value></param>
<param><key>label</key><value>Coarse Tuning (MHz)</value></param>
<param><key>value</key><value>ismband</value></param>
<param><key>min</key><value>ismband-13</value></param>
<param><key>max</key><value>ismband+13</value></param>
<param><key>num_steps</key><value>26</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>2,2,1,2</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>ismband</value></param>
<param><key>label</key><value>Band</value></param>
<param><key>value</key><value>config_ismband</value></param>
<param><key>choices</key><value>[315,433,868,915]</value></param>
<param><key>labels</key><value>['315MHz' ,'433MHz','868MHz','915MHz']</value></param>
<param><key>type</key><value>drop_down</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>2,1,1,1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_tuner_mhz</value></param>
<param><key>value</key><value>config_ismband</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>configfile</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>tuner_mhz</value></param>
<param><key>writeback</key><value>tuner_mhz</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>samp_rate</key><value>channel_rate</value></param>
<param><key>baseband_freq</key><value>channel_freq</value></param>
<param><key>dynamic_range</key><value>48</value></param>
<param><key>ref_level</key><value>-32</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>tuner_freq</value></param>
<param><key>corr0</key><value>ppmcorr</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>if_gain0</key><value>ifgain</value></param>
<param><key>bb_gain0</key><value>bbgain</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>tuner_freq</value></param>
<param><key>dynamic_range</key><value>48</value></param>
<param><key>ref_level</key><value>-32</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>channel_freq</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_ifgain</value></param>
<param><key>value</key><value>24</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>configfile</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>ifgain</value></param>
<param><key>writeback</key><value>ifgain</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>wxgui_waterfallsink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
