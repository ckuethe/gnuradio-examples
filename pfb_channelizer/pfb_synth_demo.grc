<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>pfb_synth_demo</value></param>
<param><key>author</key><value>Chris Kuethe &lt;chris.kuethe+github@gmail.com&gt;</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Polyphase Synthesizer Demo</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_map</value></param>
<param><key>value</key><value>range((num_chans+1)/2, (num_chans))+ [0] + range(1, (1+num_chans)/2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_spacing</value></param>
<param><key>value</key><value>25e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mod_width</value></param>
<param><key>value</key><value>10e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_chans</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>overclock</value></param>
<param><key>comment</key><value>allow this graph
to run faster than
realtime when
assembling large
test loads.

Pick a value that
doesn't set your
cpu on fire...</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>overclocked_rate</value></param>
<param><key>comment</key><value>Can you dig it?</value></param>
<param><key>value</key><value>overclock * oversampled_width</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>oversampled_width</value></param>
<param><key>value</key><value>chan_spacing * (num_chans + 1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pfb_sizeof_taps</value></param>
<param><key>comment</key><value>Sanity check: show
how many taps are
used for the filter.</value></param>
<param><key>value</key><value>len(pfb_taps)</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>pfb_taps</value></param>
<param><key>cutoff_freq</key><value>mod_width</value></param>
<param><key>gain</key><value>2.0</value></param>
<param><key>samp_rate</key><value>oversampled_width</value></param>
<param><key>width</key><value>2500</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>start_freq</value></param>
<param><key>value</key><value>162.4e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tau</value></param>
<param><key>comment</key><value>Experiment to
see what may
sound better.</value></param>
<param><key>value</key><value>100e-6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wav_rate</value></param>
<param><key>value</key><value>16000</value></param>
</block>
<block>
<key>analog_nbfm_tx</key>
<param><key>id</key><value>analog_nbfm_tx_0</value></param>
<param><key>audio_rate</key><value>wav_rate</value></param>
<param><key>max_dev</key><value>mod_width / 2</value></param>
<param><key>quad_rate</key><value>wav_rate</value></param>
<param><key>tau</key><value>tau</value></param>
</block>
<block>
<key>analog_nbfm_tx</key>
<param><key>id</key><value>analog_nbfm_tx_0_0</value></param>
<param><key>audio_rate</key><value>wav_rate</value></param>
<param><key>max_dev</key><value>mod_width / 2</value></param>
<param><key>quad_rate</key><value>wav_rate</value></param>
<param><key>tau</key><value>tau</value></param>
</block>
<block>
<key>analog_nbfm_tx</key>
<param><key>id</key><value>analog_nbfm_tx_0_1</value></param>
<param><key>audio_rate</key><value>wav_rate</value></param>
<param><key>max_dev</key><value>mod_width / 2</value></param>
<param><key>quad_rate</key><value>wav_rate</value></param>
<param><key>tau</key><value>tau</value></param>
</block>
<block>
<key>analog_nbfm_tx</key>
<param><key>id</key><value>analog_nbfm_tx_0_2</value></param>
<param><key>audio_rate</key><value>wav_rate</value></param>
<param><key>max_dev</key><value>mod_width / 2</value></param>
<param><key>quad_rate</key><value>wav_rate</value></param>
<param><key>tau</key><value>tau</value></param>
</block>
<block>
<key>analog_nbfm_tx</key>
<param><key>id</key><value>analog_nbfm_tx_0_3</value></param>
<param><key>audio_rate</key><value>wav_rate</value></param>
<param><key>max_dev</key><value>mod_width / 2</value></param>
<param><key>quad_rate</key><value>wav_rate</value></param>
<param><key>tau</key><value>tau</value></param>
</block>
<block>
<key>analog_nbfm_tx</key>
<param><key>id</key><value>analog_nbfm_tx_0_4</value></param>
<param><key>audio_rate</key><value>wav_rate</value></param>
<param><key>max_dev</key><value>mod_width / 2</value></param>
<param><key>quad_rate</key><value>wav_rate</value></param>
<param><key>tau</key><value>tau</value></param>
</block>
<block>
<key>analog_nbfm_tx</key>
<param><key>id</key><value>analog_nbfm_tx_0_5</value></param>
<param><key>audio_rate</key><value>wav_rate</value></param>
<param><key>max_dev</key><value>mod_width / 2</value></param>
<param><key>quad_rate</key><value>wav_rate</value></param>
<param><key>tau</key><value>tau</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>comment</key><value>Shift half a channel so
that one channel isn't
split over the spectrum
boundary, then shift half
the number of channels
so the synthesized band
is centered.</value></param>
<param><key>freq</key><value>-1.0 * (num_chans/2.0 - 0.5) * chan_spacing</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>oversampled_width</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>wav_rate</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/pfb_synth_demo.cf32</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samples_per_second</key><value>wav_rate * overclock</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/tmp/0_KJFK_slt.wav</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_1</value></param>
<param><key>file</key><value>/tmp/1_KMIA_rms.wav</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_2</value></param>
<param><key>file</key><value>/tmp/2_KSEA_slt.wav</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_3</value></param>
<param><key>file</key><value>/tmp/3_KLAX_rms.wav</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_4</value></param>
<param><key>file</key><value>/tmp/4_KDEN_slt.wav</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_5</value></param>
<param><key>file</key><value>/tmp/5_PHNL_rms.wav</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_6</value></param>
<param><key>file</key><value>/tmp/6_PANC_slt.wav</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>pfb_synthesizer_ccf</key>
<param><key>id</key><value>pfb_synthesizer_ccf_0</value></param>
<param><key>twox</key><value>False</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>ch_map</key><value>chan_map</value></param>
<param><key>numchans</key><value>num_chans+1</value></param>
<param><key>connections</key><value>num_chans+1</value></param>
<param><key>taps</key><value>pfb_taps</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>oversampled_width</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>analog_nbfm_tx_0</source_block_id><sink_block_id>pfb_synthesizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_tx_0_0</source_block_id><sink_block_id>pfb_synthesizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_nbfm_tx_0_1</source_block_id><sink_block_id>pfb_synthesizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_nbfm_tx_0_2</source_block_id><sink_block_id>pfb_synthesizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>analog_nbfm_tx_0_3</source_block_id><sink_block_id>pfb_synthesizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>analog_nbfm_tx_0_4</source_block_id><sink_block_id>pfb_synthesizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>analog_nbfm_tx_0_5</source_block_id><sink_block_id>pfb_synthesizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>pfb_synthesizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>analog_nbfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_1</source_block_id><sink_block_id>analog_nbfm_tx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_2</source_block_id><sink_block_id>analog_nbfm_tx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_3</source_block_id><sink_block_id>analog_nbfm_tx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_4</source_block_id><sink_block_id>analog_nbfm_tx_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_5</source_block_id><sink_block_id>analog_nbfm_tx_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_6</source_block_id><sink_block_id>analog_nbfm_tx_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_6</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_synthesizer_ccf_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
