<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>pfb_channelizer_demo</value></param>
<param><key>author</key><value>Chris Kuethe &lt;chris.kuethe+github@gmail.com&gt;</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>comment</key><value>Globally limit output buffer size
to reduce lag. Low rate samples
to the sound card causes high
latency when responding to UI
changes.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>max_nouts</key><value>fftwidth*2</value></param>
<param><key>title</key><value>PFB Channelizer Demo</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>chan_num</value></param>
<param><key>comment</key><value>Widget to select a
channel by name</value></param>
<param><key>value</key><value>channel_nums[0]</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>label</key><value>Channel</value></param>
<param><key>labels</key><value>channel_names</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>channel_nums</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_map</value></param>
<param><key>value</key><value>[1,2,3,5,6,7,0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_names</value></param>
<param><key>value</key><value>map(lambda x: "%.3fMHz" % (162.4 + (x*0.025)), channel_nums) </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_nums</value></param>
<param><key>comment</key><value>sorted(channel_map)</value></param>
<param><key>value</key><value>range(0,noaa_num_chans)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>comment</key><value>Decimation must
be integral. Not
casting it to int()
here serves as a
validation aid</value></param>
<param><key>value</key><value>hardware_rate / oversampled_width</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_interval</value></param>
<param><key>value</key><value>1.0/20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftwidth</value></param>
<param><key>comment</key><value>Short FFT is ok
for the narrow
audio signal

Also used to set
the output buffer
size</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hardware_rate</value></param>
<param><key>comment</key><value>1.2Msps is higher
than needed for
NOAA WX Radio.

If supported by the
receiver (eg. USRP)
sample at the actual
band width. If this is
not possible, select
a rate where
decimation % 4 ==0</value></param>
<param><key>value</key><value>int(1.2e6)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lpf_sizeof_taps</value></param>
<param><key>comment</key><value>sanity check: show
how many taps are
used for the filter.</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>len(lpf_taps)</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>lpf_taps</value></param>
<param><key>cutoff_freq</key><value>oversampled_width / 2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>hardware_rate</value></param>
<param><key>width</key><value>noaa_chan_width</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lpf_taps</value></param>
<param><key>comment</key><value>If your version of grc doesn't
have the Low-pass Filter Taps
Block, uncomment this version</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value> firdes.low_pass(1.0, hardware_rate, noaa_band_width / 2, noaa_chan_width, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noaa_band_center</value></param>
<param><key>value</key><value>noaa_band_start + (noaa_num_chans / 2 * noaa_chan_width)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noaa_band_end</value></param>
<param><key>value</key><value>noaa_band_start + (noaa_num_chans * noaa_chan_width)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noaa_band_start</value></param>
<param><key>value</key><value>162.4e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noaa_band_width</value></param>
<param><key>value</key><value>noaa_chan_width * noaa_num_chans</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noaa_chan_width</value></param>
<param><key>value</key><value>int(25e3)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noaa_fm_dev</value></param>
<param><key>value</key><value>int(5e3)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noaa_num_chans</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>oversampled_width</value></param>
<param><key>value</key><value>noaa_chan_width * (noaa_num_chans + 1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pfb_sizeof_taps</value></param>
<param><key>comment</key><value>Sanity check: show
how many taps are
used for the filter.</value></param>
<param><key>value</key><value>len(pfb_taps)</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>pfb_taps</value></param>
<param><key>cutoff_freq</key><value>noaa_fm_dev * 2</value></param>
<param><key>gain</key><value>2.0</value></param>
<param><key>samp_rate</key><value>oversampled_width</value></param>
<param><key>width</key><value>2500</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pfb_taps</value></param>
<param><key>comment</key><value>If your version of grc doesn't
have the Low-pass Filter Taps
Block, uncomment this version</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value> firdes.low_pass(2.0, oversampled_width, noaa_fm_dev * 2, 2500, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ppm</value></param>
<param><key>comment</key><value>Widget to input PPM
correction</value></param>
<param><key>value</key><value>-6.25</value></param>
<param><key>gui_hint</key><value>0,2,1,2</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-20</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ppm_corr</value></param>
<param><key>comment</key><value>Compensating for
variation in crystals,
eg. temperature or
manufacturing</value></param>
<param><key>value</key><value>tuner_freq * (ppm/1e6)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>target_freq</value></param>
<param><key>comment</key><value>Middle of the
target band</value></param>
<param><key>value</key><value>noaa_band_center</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tuner_freq</value></param>
<param><key>comment</key><value>Offset tuned to
allow the LO
leakage to be
removed by a
Low Pass Filter</value></param>
<param><key>value</key><value>162.3e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tuner_offset</value></param>
<param><key>value</key><value>target_freq - tuner_freq</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_0</value></param>
<param><key>audio_rate</key><value>noaa_chan_width</value></param>
<param><key>max_dev</key><value>noaa_fm_dev</value></param>
<param><key>maxoutbuf</key><value>fftwidth *2</value></param>
<param><key>quad_rate</key><value>noaa_chan_width</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>16000</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>noaa_num_chans</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>comment</key><value>Test recording for development.

Osmocom source straight into
file sink... 1.2Msps @ 162.3MHz</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/recording_162.3MHZ_1.2Msps.cf32</value></param>
<param><key>maxoutbuf</key><value>fftwidth</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>comment</key><value>200kSps, 7x25kHz channels.
Assembled by the polyphase
synthesizer</value></param>
<param><key>file</key><value>/tmp/pfb_synth_demo.cf32</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1 if chan_num is 0 else 0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>1 if chan_num is 1 else 0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>1 if chan_num is 2 else 0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_2</value></param>
<param><key>const</key><value>1 if chan_num is 3 else 0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_3</value></param>
<param><key>const</key><value>1 if chan_num is 4 else 0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_4</value></param>
<param><key>const</key><value>1 if chan_num is 5 else 0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_5</value></param>
<param><key>const</key><value>1 if chan_num is 6 else 0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>comment</key><value>Bypass if the audio sink
is used - it will moderate
sample consumption. If
audio is not used, then
enable this throttle.</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>hardware_rate * 4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_0</value></param>
<param><key>center_freq</key><value>tuner_offset  + ppm_corr</value></param>
<param><key>comment</key><value>Use the FFT filter here rather than
the FIR since the FFT runs in almost
constant time and the FIR is linear
with the number of taps.</value></param>
<param><key>decim</key><value>int(decimation)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>hardware_rate</value></param>
<param><key>taps</key><value>lpf_taps</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>This doesn't cause a
flowgraph reconfiguration
the way a selector does.</value></param>
<param><key>note</key><value>hacky selector</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>tuner_freq</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>comment</key><value>PPM correction not used here
because the FXFF can shift the
spectrum as needed.</value></param>
<param><key>args</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>hardware_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>pfb_channelizer_ccf</key>
<param><key>id</key><value>pfb_channelizer_ccf_0</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>ch_map</key><value>channel_map</value></param>
<param><key>nchans</key><value>noaa_num_chans+1</value></param>
<param><key>comment</key><value>Magic lives here!</value></param>
<param><key>osr</key><value>1</value></param>
<param><key>taps</key><value>pfb_taps</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>noaa_chan_width</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>fftwidth</value></param>
<param><key>gui_hint</key><value>2,0,1,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>channel_names[0]</value></param>
<param><key>label2</key><value>channel_names[1]</value></param>
<param><key>label3</key><value>channel_names[2]</value></param>
<param><key>label4</key><value>channel_names[3]</value></param>
<param><key>label5</key><value>channel_names[4]</value></param>
<param><key>label6</key><value>channel_names[5]</value></param>
<param><key>label7</key><value>channel_names[6]</value></param>
<param><key>name</key><value>"Channelizer Output"</value></param>
<param><key>nconnections</key><value>noaa_num_chans</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>fft_interval</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-20</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>noaa_chan_width</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>fftwidth</value></param>
<param><key>gui_hint</key><value>1,2,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>-37</value></param>
<param><key>int_min</key><value>-67</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>name</key><value>"Channel Monitor"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>fft_interval</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0_0</value></param>
<param><key>bw</key><value>oversampled_width</value></param>
<param><key>fc</key><value>target_freq</value></param>
<param><key>comment</key><value>Monitor the target band to ensure
that the FXFF is properly selective.</value></param>
<param><key>fftsize</key><value>fftwidth</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>-35</value></param>
<param><key>int_min</key><value>-80</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>name</key><value>"Band Monitor"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>fft_interval</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>25</value></param>
<param><key>interp</key><value>24</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>radio_samples</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>radio_samples</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>comment</key><value>The target band has been
isolated and the sampling
rate is now reduced to the
minimum required.</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>filtered_samples</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1_0</value></param>
<param><key>comment</key><value>No filtration required
for this file source.</value></param>
<param><key>stream_id</key><value>filtered_samples</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>selected_channel</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>stream_id</key><value>chan_0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3_0</value></param>
<param><key>stream_id</key><value>chan_1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3_1</value></param>
<param><key>stream_id</key><value>chan_2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3_2</value></param>
<param><key>stream_id</key><value>chan_3</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3_3</value></param>
<param><key>stream_id</key><value>chan_4</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3_4</value></param>
<param><key>stream_id</key><value>chan_5</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3_5</value></param>
<param><key>stream_id</key><value>chan_6</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>radio_samples</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>filtered_samples</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>stream_id</key><value>filtered_samples</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>selected_channel</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>chan_0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0</value></param>
<param><key>stream_id</key><value>chan_0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_1</value></param>
<param><key>stream_id</key><value>chan_1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_1_0</value></param>
<param><key>stream_id</key><value>chan_1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_2</value></param>
<param><key>stream_id</key><value>chan_2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_2_0</value></param>
<param><key>stream_id</key><value>chan_2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_3</value></param>
<param><key>stream_id</key><value>chan_3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_3_0</value></param>
<param><key>stream_id</key><value>chan_3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_4</value></param>
<param><key>stream_id</key><value>chan_4</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_4_0</value></param>
<param><key>stream_id</key><value>chan_4</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_5</value></param>
<param><key>stream_id</key><value>chan_5</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_5_0</value></param>
<param><key>stream_id</key><value>chan_5</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_6</value></param>
<param><key>stream_id</key><value>chan_6</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_6_0</value></param>
<param><key>stream_id</key><value>chan_6</value></param>
</block>
<connection><source_block_id>analog_nbfm_rx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>virtual_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_3</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_4</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_5</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>virtual_sink_3_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>virtual_sink_3_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>virtual_sink_3_2</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>virtual_sink_3_3</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>virtual_sink_3_4</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>virtual_sink_3_5</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>pfb_channelizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>analog_nbfm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_2_1_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_2</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>virtual_source_2_2_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_3</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>virtual_source_2_3_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_4</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>virtual_source_2_4_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_5</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>virtual_source_2_5_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_6</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>virtual_source_2_6_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
